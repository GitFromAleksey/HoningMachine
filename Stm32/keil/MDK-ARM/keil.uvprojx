# Keil uVision project keil.uvprojx, settings and files
target keil (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: keil +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --exceptions
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\..\Interfaces;..\..\Drivers;..\..\Model;..\..\Views\Uart;..\..\Common;..\..\Views\KeyReader
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Model
    ../../Model/: Controller.cpp machine.cpp
  group Drivers
    ../../Drivers/: AnalogInput.cpp DigitalInput.cpp DigitalOut.cpp
  group Uart
    ../../Views/Uart/: ByteReceiver.cpp ByteSender.cpp ProtocolDetector.cpp ProtocolFormer.cpp
  group Common
    ../../Common/: queue.cpp array.cpp
  group Application/User
    ../Src/: main.cpp stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group States
    ../../Model/States/: StateGeneralStop.cpp StatePositionZero.cpp StateHandHeld.cpp StateSlowSpeed.cpp StateFastReturnToOperation.cpp StateRangeSetting.cpp StateFeedEnabled.cpp StateFeedIsDisabled.cpp StateWorking.cpp StateSemenMovement.cpp StatePushing.cpp
  group Keys
    ../../Views/KeyReader/: cKeyBind.cpp cKeyHandler.cpp cKeysReader.cpp
software components: CMSIS:CORE 5.4.0
